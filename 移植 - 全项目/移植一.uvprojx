# Keil uVision project 移植一.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 移植一
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F401xx, USE_STDPERIPH_DRIVER
  c include: .\core;.\hardware;.\ports;.\start;.\user;.\library\inc;.\Trace\Cfg;.\Trace\OS;.\Trace\Segger;.\Trace\OS\Config
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group core
    ./core/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.c ucos_ii.h
  group ports
    ./ports/: os_cpu.h os_cfg.h os_cpu_c.c app_cfg.h os_cpu_a.asm myHook.c
  group start
    ./start/: startup_stm32f401xx.s core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h
  group user
    ./user/: Task.c Delay.h Task.h main.c Delay.c getdata.h getdata.c PID.c PID.h PID_Config.h Flight_Control.c Flight_Control.h
  group hardware
    ./: myScratterLoad.s
    ./hardware/: LED.c LED.h usart.c usart.h ATKBLE01.c GY86.c MyIIC.c OLED.c PPM.c PWM.c ATKBLE01.h GY86.h MyIIC.h OLED.h OLED_Font.h PWM.h ADC.c ADC.h
  group libaray
    ./library/inc/: stm32f4xx_conf.h misc.h stm32f4xx_usart.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_i2c.h stm32f4xx_tim.h stm32f4xx_adc.h
    ./library/src/: misc.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_adc.c
  group Trace_Cfg
    ./Trace/Cfg/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
  group Trace_OS
    ./Trace/OS/Config/Cortex-M/: SEGGER_SYSVIEW_Config_uCOSII.c
    ./Trace/OS/Config/: os_cfg_trace.h
    ./Trace/OS/: os_trace_events.h SEGGER_SYSVIEW_uCOSII.c
  group Trace_Segger
    ./Trace/Segger/Syscalls/: SEGGER_RTT_Syscalls_GCC.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_Syscalls_SES.c
    ./Trace/Segger/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER.h SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
